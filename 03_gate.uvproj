# Keil uVision project 03_gate.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8032 (all Variants) Generic
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: 03_gate
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 03_gate.asm clock.ini
